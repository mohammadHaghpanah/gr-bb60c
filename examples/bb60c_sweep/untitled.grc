options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    run_command: ./run_bb60c_sweep_gui.sh
    title: BB60C Sweep
  states: {}

blocks:
- name: buffer_capacity
  id: variable_qtgui_range
  parameters:
    comment: Construction-only; change requires restart
    gui_hint: 5, 1, 1, 1
    label: Buffer Capacity
    rangeType: int
    start: '1'
    step: '1'
    stop: '256'
    value: '32'
  states: {}
- name: detector
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 4, 0, 1, 1
    label: Detector
    label0: Min and Max
    label1: Average
    num_opts: '2'
    option0: '0'
    option1: '1'
    options: '[0, 1]'
    type: int
    value: '1'
  states: {}
- name: rbw
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 0, 1, 1
    label: RBW (Hz)
    start: 1e3
    step: 1e3
    stop: 10e6
    value: 100e3
  states: {}
- name: rbw_shape
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3, 0, 1, 1
    label: RBW Shape
    label0: Nuttall
    label1: Flattop
    label2: CISPR
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '1'
  states: {}
- name: ref_level
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1, 1
    label: Ref Level (dBm)
    start: '-50'
    step: '1'
    stop: '20'
    value: '-20.0'
  states: {}
- name: rejection
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3, 1, 1, 1
    label: Spur Rejection
    label0: No Spur Reject
    label1: Spur Reject
    num_opts: '2'
    option0: '0'
    option1: '1'
    options: '[0, 1]'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: scale
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 4, 1, 1, 1
    label: Scale
    label0: Log
    label1: Linear
    label2: Log Full Scale
    label3: Linear Full Scale
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    options: '[0, 1, 2, 3]'
    type: int
    value: '0'
  states: {}
- name: start_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0, 1, 1
    label: Start Freq (Hz)
    start: 9e6
    step: 1e6
    stop: 6e9
    value: 900e6
  states: {}
- name: stop_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 1, 1, 1
    label: Stop Freq (Hz)
    start: 9e6
    step: 1e6
    stop: 6e9
    value: 1000e6
  states: {}
- name: sweep_time
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 1, 1, 1
    label: Sweep Time (s)
    start: '0.001'
    step: '0.001'
    stop: '1'
    value: '0.01'
  states: {}
- name: units
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 5, 0, 1, 1
    label: Units
    label0: Log (dBm)
    label1: Voltage
    label2: Power
    label3: Sample
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    options: '[0, 1, 2, 3]'
    type: int
    value: '0'
  states: {}
- name: vbw
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 1, 1, 1
    label: VBW (Hz)
    start: 1e3
    step: 1e3
    stop: 10e6
    value: 100e3
  states: {}
- name: bb60c_bb60c_sweep_0
  id: bb60c_bb60c_sweep
  parameters:
    buffer_capacity: buffer_capacity
    detector: detector
    rbw: rbw
    rbw_shape: rbw_shape
    ref_level: ref_level
    rejection: rejection
    scale: scale
    start_freq: start_freq
    stop_freq: stop_freq
    sweep_time: sweep_time
    units: units
    vbw: vbw
  states: {}
- name: bb60c_set_time_sink_nsamps_0
  id: bb60c_set_time_sink_nsamps
  parameters:
    time_sink: qtgui_time_sink_x_0
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    axislabels: 'False'
    color1: yellow
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 6, 0, 4, 2
    label1: ''
    legend: 'False'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"sweep_start"'
    type: float
  states: {}

connections:
- [bb60c_bb60c_sweep_0, '0', qtgui_time_sink_x_0, '0']
- [bb60c_bb60c_sweep_0, num_points, bb60c_set_time_sink_nsamps_0, inpair]

metadata:
  file_format: 1
